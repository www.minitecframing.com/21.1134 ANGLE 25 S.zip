# Autodesk Inventor assembly: 21.1134 ANGLE 25 S
## iProperties
Created: 2007-01
Part Number: 21.1134 ANGLE 25 S
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
